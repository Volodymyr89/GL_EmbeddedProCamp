# Keil uVision project LED_Blink.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.0.1
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) IRAM2(0x10000000,0x2000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED_Blink
  c flags: Optim=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group LED_Blink
    ./: LED_Blink.c
  group ::Device
    RTE/Device/STM32F303VC/: startup_stm32f30x.s system_stm32f30x.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
